# Keil uVision project stabilcd.uvprojx, settings and files
target stabilcd (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stabilcd +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO, __FPU_USED
  c include: .\src;.\CMSIS;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F429I-Discovery
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stabilcd.sct
  group startup
    ./startup/: startup_stm32f429_439xx.s
  group STM32F429I-Discovery
    ./STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_i3g4250d.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c misc.c stm32f4xx_dma.c stm32f4xx_syscfg.c stm32f4xx_spi.c
  group src
    ./src/: fonts.c main.c stm32f4xx_it.c system_stm32f4xx.c bmp.s
